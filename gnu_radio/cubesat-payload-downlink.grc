options:
  parameters:
    generate_options: qt_gui
    id: cubesat_payload_downlink
    output_language: python
    title: 915 MHz Downlink
  states: {}

blocks:
- name: frame_payload_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: header_format
  id: variable
  parameters:
    value: digital.header_format_default("10101100110111011010010011100010", 0, 1)
  states: {}
- name: noise_value
  id: variable_qtgui_range
  parameters:
    label: Noise
    min_len: '1'
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '800000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_value
    noise_type: analog.GR_GAUSSIAN
    seed: '11'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/bdon/University/capstone/jpg/img1.ppm
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[2, 256]'
    type: byte
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: '[258, 1]'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_payload_size+2
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '64'
    type: byte
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: samp_rate
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '3'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[85]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[b for n in range(65536) for b in (n >> 8, n & 255)]'
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0]'
  states: {}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: short
    vector: '[1]*258 + [0]'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"10101100110111011010010011100010"'
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '8'
    sensitivity: '0.3926990817'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '8'
    sensitivity: '0.3926990817'
  states: {}
- name: digital_protocol_formatter_bb_1
  id: digital_protocol_formatter_bb
  parameters:
    format: header_format
    len_tag_key: '"packet_len"'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '25000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: file_bytestream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: frame_tx
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: deframe_rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: frame_tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: file_bytestream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: deframe_rx
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_burst_tagger_0, '0', blocks_tagged_file_sink_0, '0']
- [blocks_file_source_0_0, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_mux_1, '0', blocks_burst_tagger_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_1, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_1, '0', blocks_stream_mux_1, '1']
- [blocks_vector_source_x_1_0, '0', blocks_burst_tagger_0, '1']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '2']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_1, '0']
- [digital_crc32_bb_0_0, '0', blocks_stream_mux_1, '0']
- [digital_gfsk_demod_0, '0', virtual_sink_3, '0']
- [digital_gfsk_mod_0, '0', blocks_add_xx_0, '1']
- [digital_protocol_formatter_bb_1, '0', blocks_tagged_stream_mux_0, '1']
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', digital_gfsk_mod_0, '0']
- [virtual_source_1, '0', blocks_stream_mux_0, '1']
- [virtual_source_2, '0', digital_correlate_access_code_xx_ts_0, '0']

metadata:
  file_format: 1
